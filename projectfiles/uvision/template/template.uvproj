# Keil uVision project template.uvproj, settings and files
target template (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: IRAM(0x0-0x0) IRAM2(0x0-0x0) IROM(0x0-0x0) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: template +hex
  AfterMake: ..\..\scripts\fromelf_append.bat "#KARM\ARMCC\bin\fromelf --bin $L@L.axf -o $L@L" "#KARM\ARMCC\bin\fromelf --text -s $L@L.axf -o $L@L\symbols"
  AfterMake: python ..\..\scripts\generate_blobs.py $L@L
  c flags: Optim=1 OneElfS=1 uC99=1
  c misc: --gnu --c99
  c include: ..\..\..\source;  ..\..\..\source\template;
  scatter file: ..\..\..\source\FlashAlgo.lin
  group flash_driver
    ../../../source/template/: FlashDev.c FlashPrg.c
