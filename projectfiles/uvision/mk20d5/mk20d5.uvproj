# Keil uVision project mk20d5.uvproj, settings and files
target mk20d5 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: IRAM(0x0-0x0) IRAM2(0x0-0x0) IROM(0x0-0x0) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: mk20d5 +hex
  AfterMake: ..\..\scripts\fromelf_append.bat "#KARM\ARMCC\bin\fromelf --bin $L@L.axf -o $L@L" "#KARM\ARMCC\bin\fromelf --text -s $L@L.axf -o $L@L\symbols"
  AfterMake: python ..\..\scripts\generate_blobs.py $L@L
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __NO_EMBEDDED_ASM,  CPU_MK20DX128VLF5,
  c misc: --gnu --c99
  c include: ..\..\..\source;  ..\..\..\source\freescale;  ..\..\..\source\freescale\driver;  ..\..\..\source\freescale\devices;
  asm define: __NO_EMBEDDED_ASM,  CPU_MK20DX128VLF5,
  scatter file: ..\..\..\source\FlashAlgo.lin
  group default
    ../../../source/freescale/driver/: flash_densities_k_series.c
  group flash_driver
    ../../../source/freescale/: FlashDev.c FlashPrg.c
    ../../../source/freescale/driver/: flash_init.c flash_erase.c flash_program.c flash_erase_all.c flash_verify_erase.c flash_get_property.c flash_verify_program.c flash_verify_erase_all.c flash_command_sequence.c
