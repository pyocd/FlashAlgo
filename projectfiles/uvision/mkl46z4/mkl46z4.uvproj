# Keil uVision project mkl46z4.uvproj, settings and files
target mkl46z4 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: IRAM(0x0-0x0) IRAM2(0x0-0x0) IROM(0x0-0x0) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: mkl46z4 +hex
  AfterMake: ..\..\scripts\fromelf_append.bat "#KARM\ARMCC\bin\fromelf --bin $L@L.axf -o $L@L" "#KARM\ARMCC\bin\fromelf --text -s $L@L.axf -o $L@L\symbols"
  AfterMake: python ..\..\scripts\generate_blobs.py $L@L
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __NO_EMBEDDED_ASM,  CPU_MKL46Z256VLH4,
  c misc: --gnu --c99
  c include: ..\..\..\source;  ..\..\..\source\freescale;  ..\..\..\source\freescale\driver;  ..\..\..\source\freescale\devices;
  asm define: __NO_EMBEDDED_ASM,  CPU_MKL46Z256VLH4,
  scatter file: ..\..\..\source\FlashAlgo.lin
  group default
    ../../../source/freescale/driver/: flash_densities_kl_series.c
  group flash_driver
    ../../../source/freescale/: FlashDev.c FlashPrg.c
    ../../../source/freescale/driver/: flash_init.c flash_erase.c flash_program.c flash_erase_all.c flash_verify_erase.c flash_get_property.c flash_verify_program.c flash_verify_erase_all.c flash_command_sequence.c
